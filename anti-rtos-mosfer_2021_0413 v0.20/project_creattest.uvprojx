# Keil uVision project project_creattest.uvprojx, settings and files
target Mosfet (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TLE9854QX Infineon
  pack: Infineon.TLE985x_DFP.1.1.8
  cpu: IRAM(0x18000000,0x1000) IROM(0x11000000,0x10000) IROM2(0x10FFFFFC,4) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project_creattest
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\anti-rtos-mosfer_2021_0413 v0.20;.\wyattEdit\INC;.\lin_driver
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0xf000
  memory RVCT5: ROM 0x10fffffc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1000
  group mosfetdriver
    ./: main.c project schedule.txt Parameters.c
    ./wyattEdit/INC/: Motor_Parameter.h ProjectHeaders.h
  group DataLevel
    ./wyattEdit/SRC/: AntiPinch_Serve.c MotorContol_Serve.c MotorStalling_Serve.c PIFunc.c Position_Serve.c Speed_Serve.c AppLogic.c Key_Serve.c
    ./wyattEdit/INC/: AntiPinch_Serve.h MotorControl_Serve.h MotorStalling_Serve.h PIFunc.h Position_Serve.h Speed_Serve.h AppLogic.h Key_Serve.h
    ./: Method_Serve.c Method_Serve.h
  group Hardware
    ./wyattEdit/SRC/: Interrupt_Serve.c PWM_Serve.c
    ./wyattEdit/INC/: Interrupt_Serve.h PWM_Serve.h
    ./: EPROM_Serve.c EEPROM_Serve.h LIN_Serve.c LIN_Serve.h MyAdc_Serve.c MyAdc_Serve.h
  group lin_a
    ./lin_driver/: lin_config.c lin_config.h lin_diagnostic_service.c lin_diagnostic_service.h lin_diagnostic_support.c lin_diagnostic_support.h lin_hal.c lin_hal.h lin_il.c lin_il.h lin_protocol.c lin_protocol.h lin_tl_protocol.c lin_tl_protocol.h lin_transceiver.c lin_transceiver.h
software components: CMSIS:CORE 5.4.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.6, Device:SDK:ADC2 0.3.3, Device:SDK:BDRV 0.2.7, Device:SDK:BOOTROM 0.2.2, Device:SDK:CCU6 0.3.0, Device:SDK:GPT12E 0.2.2, Device:SDK:INT 0.2.2, Device:SDK:ISR 0.2.3, Device:SDK:LIN 0.2.3, Device:SDK:PMU 0.2.2, Device:SDK:PORT 0.2.2, Device:SDK:SCU 0.2.5, Device:SDK:UART 0.2.4, Device:SDK:WDT1 0.2.2, Device:Startup 0.1.0, RTOS:kernel 3.1.3
